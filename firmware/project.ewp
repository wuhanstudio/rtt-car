# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VE ST STM32L475VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L475xx; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: rt-thread\components\net\sal_socket\include\socket\sys_socket; rt-thread\include; rt-thread\components\net\sal_socket\include\dfs_net\sys_select; rt-thread\components\dfs\filesystems\devfs; rt-thread\components\net\sal_socket\include\dfs_net; rt-thread\libcpu\arm\common; ports\fal; rt-thread\components\net\lwip-2.0.2\src; libraries\CMSIS\Device\ST\STM32L4xx\Include; packages\protobuf-c-latest\src; rt-thread\components\finsh; rt-thread\components\net\lwip-2.0.2\src\include; libraries\wifi; packages\onnx-backend-latest\examples; ports\easyflash; rt-thread\components\net\lwip-2.0.2\src\include\ipv4; packages\onnx-backend-latest\src; drivers; packages\onnx-parser-latest\examples; packages\protobuf-c-latest\examples; .; packages\webnet-v2.0.1\inc; rt-thread\components\drivers\include; packages\netutils-v1.1.0\telnet; rt-thread\components\libc\compilers\dlib; rt-thread\components\net\netdev\include; packages\netutils-v1.1.0\tftp; rt-thread\components\net\lwip-2.0.2\src\arch\include; packages\onnx-parser-latest\src; rt-thread\libcpu\arm\cortex-m4; packages\fal-v0.2.0\inc; applications; packages\stm32_sdio-v1.0.2; libraries\STM32L4xx_HAL_Driver\inc; rt-thread\components\net\lwip-2.0.2\src\include\netif; rt-thread\components\drivers\spi\sfud\inc; libraries\CMSIS\Include; rt-thread\components\dfs\include; rt-thread\components\dfs\filesystems\elmfat; rt-thread\components\drivers\wlan; rt-thread\components\libc\compilers\common; rt-thread\components\net\sal_socket\impl; packages\EasyFlash-v3.2.1\inc; ports\wifi; rt-thread\components\net\sal_socket\include; libraries\rt_ota\inc; rt-thread\components\drivers\spi; rt-thread\components\net\sal_socket\include\socket
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../rt-thread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\stm32l475ve.icf
  ILINK.IlinkAdditionalLibs: libraries\rt_ota\libs\librt_ota_noalgo_0.1.2_stm32l4_iar.a; libraries\wifi\libwifi_6181_0.2.5_armcm4_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Kernel
    rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c robot.c
  group Drivers
    drivers/: board.c drv_clock.c drv_gpio.c drv_qspi_flash.c drv_spi_tfcard.c drv_usart.c drv_spi.c drv_sdio_adapter.c drv_qspi.c drv_wlan.c drv_pwm.c
  group STM32L4xx_HAL_Driver
    libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l475xx.s
    libraries/STM32L4xx_HAL_Driver/src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_spi.c stm32l4xx_hal_qspi.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group wifi
    ports/wifi/: wifi_config.c
  group EasyFlash
    packages/EasyFlash-v3.2.1/src/: easyflash.c ef_cmd.c ef_env.c ef_env_wl.c ef_iap.c ef_log.c ef_utils.c
    ports/easyflash/: ef_fal_port.c
  group fal
    packages/fal-v0.2.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ports/fal/: fal_flash_sfud_port.c fal_flash_stm32l4_port.c
  group NetUtils
    packages/netutils-v1.1.0/telnet/: telnet.c
    packages/netutils-v1.1.0/tftp/: tftp_port.c tftp_server.c
  group onnx-backend
    packages/onnx-backend-latest/src/: add.c conv2d.c dense.c info.c matmul.c maxpool.c model.c relu.c softmax.c transpose.c
    packages/onnx-backend-latest/examples/: mnist_model.c
  group onnx-parser
    packages/onnx-parser-latest/src/: onnx-parser.c onnx.pb-c.c
  group protobuf-c
    packages/protobuf-c-latest/src/: protobuf-c.c
  group stm32_sdio
    packages/stm32_sdio-v1.0.2/: stm32_sdio.c
  group WebNet
    packages/webnet-v2.0.1/src/: webnet.c wn_mimetype.c wn_request.c wn_session.c wn_utils.c wn_module.c
    packages/webnet-v2.0.1/module/: wn_module_asp.c wn_module_auth.c wn_module_cgi.c wn_module_index.c wn_module_alias.c wn_module_upload.c wn_module_ssi.c
    packages/webnet-v2.0.1/samples/: wn_sample.c wn_sample_upload.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_msd.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group finsh
    rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    rt-thread/components/libc/compilers/common/: gmtime_r.c
  group dlib
    rt-thread/components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group lwIP
    rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group netdev
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
